# Keil uVision project 温度传感器.uvproj, settings and files
target Target 1 (MCS-51)
  device: Nexar TSK51 Altium
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF) CLOCK(44000000)
  output: 温度传感器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c temp.c
